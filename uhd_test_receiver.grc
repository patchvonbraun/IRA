<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_test_receiver</value></param>
<param><key>title</key><value>Integrated Radio Astronomy Receiver</value></param>
<param><key>author</key><value>Marcus Leech</value></param>
<param><key>description</key><value>gnuradio flow graph</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import window</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_2</value></param>
<param><key>import</key><value>from gnuradio import gr</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_4</value></param>
<param><key>import</key><value>import iraconfig</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>55</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import sys</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ratepsr</value></param>
<param><key>value</key><value>8000</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devaddr</value></param>
<param><key>value</key><value>addr=192.168.10.2</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>adrate</value></param>
<param><key>label</key><value>adrate</value></param>
<param><key>value</key><value>int(64.0e6)</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>gr_fft_vxx</key>
<param><key>id</key><value>gr_fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>int(setisize)</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(int(bandwidth))</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>gr_complex_to_mag</key>
<param><key>id</key><value>gr_complex_to_mag_0</value></param>
<param><key>vlen</key><value>int(setisize)</value></param>
</block>
<block>
<key>gr_stream_to_vector</key>
<param><key>id</key><value>gr_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>int(setisize)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>int(ibandwidth/ratepsr)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_single_pole_iir_filter_xx</key>
<param><key>id</key><value>gr_single_pole_iir_filter_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>1.0/(bandwidth/(ratepsr/2.0))</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_3</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_bus_bw</value></param>
<param><key>value</key><value>25.0e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>inotches</value></param>
<param><key>value</key><value>iraconfig.compute_notches(notch_freqs,int(notch_len),bandwidth,ifreq,idm)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>notch_freqs</value></param>
<param><key>value</key><value>[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>igain</value></param>
<param><key>value</key><value>gain</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>notch_len</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pid</value></param>
<param><key>value</key><value>iraconfig.writepid()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>seti_rate</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ibandwidth</value></param>
<param><key>value</key><value>bandwidth if bandwidth &lt;= max_bus_bw else max_bus_bw</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>SETI/Spectral sub-graph</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>idm</value></param>
<param><key>value</key><value>dm</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>port</key><value>11420</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>De-dispersion filter only for &lt;= dfiltsize</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>3.0e4</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_complex_to_mag_squared</key>
<param><key>id</key><value>gr_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Total power and pulsar sub-graph</value></param>
</block>
<block>
<key>gr_single_pole_iir_filter_xx</key>
<param><key>id</key><value>gr_single_pole_iir_filter_xx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>1.0/binwidth</value></param>
<param><key>vlen</key><value>int(setisize)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dfiltsize</value></param>
<param><key>label</key><value>dfiltsize</value></param>
<param><key>value</key><value>65536</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sky</value></param>
<param><key>label</key><value>sky</value></param>
<param><key>value</key><value>250.0e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cdoppler</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dev_addr</key><value>devaddr</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>ibandwidth</value></param>
<param><key>center_freq0</key><value>ifreq+(skyfreq*cdoppler)</value></param>
<param><key>gain0</key><value>igain</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dm</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ifreq</value></param>
<param><key>value</key><value>freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>VARDUMP</value></param>
<param><key>value</key><value>iraconfig.writevars(["skyfreq","cdoppler","combo"], [skyfreq,cdoppler,ifreq+(skyfreq*cdoppler)])</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_1</value></param>
<param><key>file</key><value>/dev/null</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0_0</value></param>
<param><key>file</key><value>/dev/null</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>int(setisize)</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>1420.4058e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>binwidth</value></param>
<param><key>label</key><value>binwidth</value></param>
<param><key>value</key><value>10</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>label</key><value>bandwidth</value></param>
<param><key>value</key><value>10e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>gr_fft_filter_xxx</key>
<param><key>id</key><value>gr_fft_filter_xxx_1</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>inotches</value></param>
</block>
<block>
<key>gr_fft_filter_xxx</key>
<param><key>id</key><value>gr_fft_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>iraconfig.compute_dispfilter(idm,(1.0-cdoppler),ibandwidth,skyfreq)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>skyfreq</value></param>
<param><key>value</key><value>freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dedisperse_size</value></param>
<param><key>value</key><value>len(iraconfig.compute_dispfilter(idm,1.0,ibandwidth,skyfreq))</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>setisize</value></param>
<param><key>value</key><value>262144</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>gr_keep_one_in_n</key>
<param><key>id</key><value>gr_keep_one_in_n_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>int(bandwidth/setisize)/seti_rate</value></param>
<param><key>vlen</key><value>int(setisize)</value></param>
</block>
<connection><source_block_id>gr_stream_to_vector_0</source_block_id><sink_block_id>gr_fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_vxx_0</source_block_id><sink_block_id>gr_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_0</source_block_id><sink_block_id>gr_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_squared_0</source_block_id><sink_block_id>gr_single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_0</source_block_id><sink_block_id>gr_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_0</source_block_id><sink_block_id>gr_single_pole_iir_filter_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_fft_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_filter_xxx_1</source_block_id><sink_block_id>gr_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_filter_xxx_1</source_block_id><sink_block_id>gr_fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_filter_xxx_0</source_block_id><sink_block_id>gr_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_single_pole_iir_filter_xx_1</source_block_id><sink_block_id>gr_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_keep_one_in_n_1</source_block_id><sink_block_id>gr_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
